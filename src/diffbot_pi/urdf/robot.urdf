Commit message: add rplidar

File: src/diffbot_pi/urdf/robot.urdf (robot description, URDF)
Before this commit: robot diffbot_pi, 5 links, 4 joints
Links:
- link laser: geometry visual cylinder length=0.04 radius=0.035
